## board/rugo/Kconfig
```kconfig
if TARGET_RUGO

config SYS_BOARD
	default "rugo"

config SYS_CONFIG_NAME
	default "rugo"
 
endif
```
